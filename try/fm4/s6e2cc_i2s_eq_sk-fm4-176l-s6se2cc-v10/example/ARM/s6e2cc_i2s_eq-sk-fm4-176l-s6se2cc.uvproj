# Keil uVision project s6e2cc_i2s_eq-sk-fm4-176l-s6se2cc.uvproj, settings and files
target S6E2CC8x0A_Debug (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: s6e2cc_i2s_eq-sk-fm4-176l-s6se2cc
  c flags: Optim=1
  c include: ..\..\common;..\..\example\source
  memory RVCT4: ROM 0x1fff0000 size 0x10000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x20038000 size 0x8000
  memory RVCT10: RAM 0x20040000 size 0x8000
  group common
    ../../common/: system_s6e2cc.c
  group source_files
    ../source/: main.c i2c.c i2scodec_WM8731.c pixiedust_sound_i2s.c
    ../../: Readme.txt
    ./: startup_s6e2cc.s
target S6E2CC9x0A_Debug (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: s6e2cc_i2s_eq-sk-fm4-176l-s6se2cc
  c flags: Optim=1
  c include: ..\..\common;..\..\example\source
  memory RVCT4: ROM 0x1ffe0000 size 0x20000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x20038000 size 0x8000
  memory RVCT10: RAM 0x20040000 size 0x8000
target S6E2CCAx0A_Debug (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: s6e2cc_i2s_eq-sk-fm4-176l-s6se2cc
  c flags: Optim=1
  c include: ..\..\common;..\..\example\source
  memory RVCT4: ROM 0x1ffd0000 size 0x30000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x20038000 size 0x8000
  memory RVCT10: RAM 0x20040000 size 0x8000
target S6E2CC8x0A_Release (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: s6e2cc_i2s_eq-sk-fm4-176l-s6se2cc +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\example\source
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20038000 size 0x10000
target S6E2CC9x0A_Release (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: s6e2cc_i2s_eq-sk-fm4-176l-s6se2cc +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\example\source
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1ffe0000 size 0x20000
  memory RVCT10: RAM 0x20038000 size 0x10000
target S6E2CCAx0A_Release (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: s6e2cc_i2s_eq-sk-fm4-176l-s6se2cc +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\example\source;..\..\library\driver
  memory RVCT4: ROM 0x0 size 0x300000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1ffd0000 size 0x30000
  memory RVCT10: RAM 0x20038000 size 0x10000
