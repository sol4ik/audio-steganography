# Keil uVision project s6e2cc_i2s_eq-sk-fm4-176l-s6se2cc.uvprojx, settings and files
target S6E2CCAx0A_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: s6e2cc_i2s_eq-sk-fm4-176l-s6se2cc +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM4
  c include: ..\..\common;..\..\example\source;..\..\library\driver;..\..\..\..\..\Documents\Cypress\PDL\2.1.0\cmsis\include
  memory RVCT4: ROM 0x0 size 0x300000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1ffd0000 size 0x30000
  memory RVCT10: RAM 0x20038000 size 0x10000
  group common
    ../../common/: system_s6e2cc.c
  group source_files
    ../source/: main.c i2c.c i2scodec_WM8731.c buffer.c equalizer.c idlemeasurement.c uart.c uartdraw.c userio.c windowfunction.c globals.h
    ../../: Readme.txt
    ./: startup_s6e2cc.s
software components: CMSIS:DSP 1.4.1
