<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\s6e2cc_i2s-sk-fm4-176l-s6se2cc.ewp</path>
  </project>
  <batchBuild/>
</workspace>


