# IAR project s6e2cc_i2s-sk-fm4-176l-s6se2cc.ewp, settings and files
configuration S6E2CCAx0A_Release (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF568R Spansion MB9BF568R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\example\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e2cc_i2s-sk-fm4-176l-s6se2cc.srec
  ILINK.IlinkOutputFile: s6e2cc_i2s-sk-fm4-176l-s6se2cc.out
  ILINK.IlinkIcfFile: config\s6e2ccax0a.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: Readme.txt
  group common
    ../../common/: system_s6e2cc.c
  group source_files
    ../source/: i2c.c i2scodec_WM8731.c main.c pixiedust_sound_i2s.c
    ./: startup_s6e2cc.s
